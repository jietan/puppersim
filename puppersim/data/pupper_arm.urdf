Commit message: update urdf to make arm vertical

File: puppersim/data/pupper_arm.urdf (robot description, URDF)
Before this commit: robot pupper_arm, 5 links, 4 joints
Joints:
- joint leftFrontUpperLegMotor: origin xyz=0.0395 0.0265 0 rpy=0 0 0 -> xyz=0.0395 0.0265 0 rpy=1.5708 0 0
